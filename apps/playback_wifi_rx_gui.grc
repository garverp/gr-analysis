<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_rx_gui</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_size</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_length</value></param>
<param><key>value</key><value>320</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>25e6</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>sync_length</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>ieee802_11_moving_average_xx</key>
<param><key>id</key><value>ieee802_11_moving_average_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>length</key><value>window_size</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(64)</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>ieee802_11_ether_encap</key>
<param><key>id</key><value>ieee802_11_ether_encap_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>ifn</key><value>tap0</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>tech</key><value>127</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_moving_average_xx</key>
<param><key>id</key><value>ieee802_11_moving_average_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>length</key><value>window_size + 16</value></param>
</block>
<block>
<key>ieee802_11_ofdm_decode_signal</key>
<param><key>id</key><value>ieee802_11_ofdm_decode_signal_0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>16</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/dev/null</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/data/spectrum_records/1-nov-2014-game/s2l2/2462_25_1630_NorthToCorner.sc16</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>10000000</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>ieee802_11_ofdm_parse_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_parse_mac_0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_ofdm_sync_long</key>
<param><key>id</key><value>ieee802_11_ofdm_sync_long_0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>sync_length</key><value>sync_length</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"acorr_peak"</value></param>
</block>
<block>
<key>ieee802_11_ofdm_sync_short</key>
<param><key>id</key><value>ieee802_11_ofdm_sync_short_0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>threshold</key><value>0.85 * 0.8</value></param>
<param><key>max_samples</key><value>80 * 160</value></param>
<param><key>min_plateau</key><value>2</value></param>
</block>
<block>
<key>ieee802_11_ofdm_decode_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_decode_mac_0</value></param>
<param><key>log</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_ofdm_equalize_symbols</key>
<param><key>id</key><value>ieee802_11_ofdm_equalize_symbols_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>ofdm_decode</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_short_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_short_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_long_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_equalize_symbols_0</source_block_id><sink_block_id>ieee802_11_ofdm_decode_signal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_decode_signal_0</source_block_id><sink_block_id>ieee802_11_ofdm_decode_mac_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>ieee802_11_ofdm_equalize_symbols_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_1</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>ieee802_11_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>ieee802_11_moving_average_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_decode_mac_0</source_block_id><sink_block_id>ieee802_11_ofdm_parse_mac_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_decode_mac_0</source_block_id><sink_block_id>ieee802_11_ether_encap_0</sink_block_id><source_key>out</source_key><sink_key>from wifi</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_decode_mac_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_ether_encap_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0</sink_block_id><source_key>to tap</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_short_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_equalize_symbols_0</source_block_id><sink_block_id>blocks_tag_debug_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
