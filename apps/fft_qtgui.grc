<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_fft</value></param>
<param><key>title</key><value>QT FFT</value></param>
<param><key>author</key><value>Example</value></param>
<param><key>description</key><value>Power Spectral Density</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_gain</value></param>
<param><key>label</key><value>Default Gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>25000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_freq</value></param>
<param><key>label</key><value>Default Frequency</value></param>
<param><key>value</key><value>2.437e9</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>RX Tune Frequency</value></param>
<param><key>value</key><value>param_freq</value></param>
<param><key>start</key><value>70000000</value></param>
<param><key>stop</key><value>6000000000</value></param>
<param><key>step</key><value>100000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>samp_rate</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>ant</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Time Domain - Mag Squared</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Spectrogram</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>int_min</key><value>-130</value></param>
<param><key>int_max</key><value>-40</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>color1</key><value>6</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>name</key><value>Mag2 Histogram</value></param>
<param><key>size</key><value>1000000</value></param>
<param><key>bins</key><value>1024</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>xmax</key><value>1</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>address</value></param>
<param><key>label</key><value>IP Address</value></param>
<param><key>value</key><value>"type=b200"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>a</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ant</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>option0</key><value>TX/RX</value></param>
<param><key>label0</key><value>TX/RX</value></param>
<param><key>option1</key><value>RX2</value></param>
<param><key>label1</key><value>RX2</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>"Spectrum"</value></param>
<param><key>label1</key><value>"Time and ADC"</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>FFT</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>ymin</key><value>-130</value></param>
<param><key>ymax</key><value>-40</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>4e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>value</key><value>35</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>label5</key><value>Tab 5</value></param>
<param><key>label6</key><value>Tab 6</value></param>
<param><key>label7</key><value>Tab 7</value></param>
<param><key>label8</key><value>Tab 8</value></param>
<param><key>label9</key><value>Tab 9</value></param>
<param><key>label10</key><value>Tab 10</value></param>
<param><key>label11</key><value>Tab 11</value></param>
<param><key>label12</key><value>Tab 12</value></param>
<param><key>label13</key><value>Tab 13</value></param>
<param><key>label14</key><value>Tab 14</value></param>
<param><key>label15</key><value>Tab 15</value></param>
<param><key>label16</key><value>Tab 16</value></param>
<param><key>label17</key><value>Tab 17</value></param>
<param><key>label18</key><value>Tab 18</value></param>
<param><key>label19</key><value>Tab 19</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>address</value></param>
<param><key>label</key><value>IP Address</value></param>
<param><key>value</key><value>"type=b200"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>a</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
